options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Project
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: OpenHT TX path sim
  states: {}

blocks:
- name: N1
  id: variable
  parameters:
    value: '405'
  states: {}
- name: N2
  id: variable
  parameters:
    value: '205'
  states: {}
- name: N3
  id: variable
  parameters:
    value: '100'
  states: {}
- name: fm_dev
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: gain_1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: gain_2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: gain_3
  id: variable
  parameters:
    value: '2'
  states: {}
- name: interp_1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: interp_2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: interp_3
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: taps_1
  id: variable
  parameters:
    value: scisig.remez(N1, [0, 3800, 4200, samp_rate*interp_1/2], [1.0, 0], fs=samp_rate*interp_1)
  states: {}
- name: taps_2
  id: variable
  parameters:
    value: scisig.remez(N2, [0, 4400, 10000, samp_rate*interp_1*interp_2/2], [1.0, 0], fs=samp_rate*interp_1*interp_2)
  states: {}
- name: taps_3
  id: variable
  parameters:
    value: scisig.remez(N3, [0, 4400, 30000, samp_rate*interp_1*interp_2*interp_3/2], [1.0, 0], fs=samp_rate*interp_1*interp_2*interp_3)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*fm_dev)/(samp_rate*interp_1*interp_2*interp_3)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: samples/1.aud
    repeat: 'True'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: interp_1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: interp_2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: interp_3
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**16/2
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*interp_1*interp_2*interp_3
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from scipy import signal as scisig
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_1
    taps: taps_1
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_2
    taps: taps_2
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: interp_3
    taps: taps_3
    type: fff
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '17005'
    send_eof: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interp_1*interp_2*interp_3
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*interp_1*interp_2*interp_3
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    legend: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    legend: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    legend: 'False'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    legend: 'False'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*interp_1*interp_2*interp_3
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    legend: 'False'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', interp_fir_filter_xxx_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle2_0, '0']
- [analog_noise_source_x_0, '0', interp_fir_filter_xxx_0, '0']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_noise_source_x_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', interp_fir_filter_xxx_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', network_udp_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [interp_fir_filter_xxx_0_1, '0', blocks_multiply_const_vxx_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
